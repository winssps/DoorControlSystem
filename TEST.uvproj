# Keil uVision project TEST.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC89C52RC STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(45000000) MODP2
  output: TEST +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: lcd1602.c main.c rc522.c lcd1602.h main.h rc522.h
